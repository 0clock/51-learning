# Keil uVision project Template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library\inc;.\USER
  group USER
    ./USER/: main.c main.h
