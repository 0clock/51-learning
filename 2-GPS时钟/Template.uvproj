# Keil uVision project Template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library\inc
  group USER
    ./USER/: main.c main.h
  group Library
    ./Library/src/: bme280.c BMP.c delay.c GPS.c iic.c key.c OLED_GUI.c oled.c Rotary_Encoder.c SPI.c
