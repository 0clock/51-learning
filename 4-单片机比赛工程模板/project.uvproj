# Keil uVision project project.uvproj, settings and files
target Debug (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library\inc;.\USER
  group USER
    ./USER/: main.c main.h STC12C5A60S2.H
  group Library
    ./Library/src/: ADC.c AT24C02.c Digital_tube.c DS18B20.c ds1302.c int_it.c IO_expand.c LCD1602.c parallel_12864.c PCF8591.c PWM.c stepper_motor.c time.c usart.c HX711.c as608.c buzz.c delay.c mpu6050.c key.c
